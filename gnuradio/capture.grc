options:
  parameters:
    generate_options: qt_gui
    id: capture
    output_language: python
    title: capture
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 2.4e9 + 128e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '5000000'
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: 1.2e6
    audio_stop: 1.6e6
    chan_rate: samp_rate
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: file_name
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_addr: '"addr=192.168.10.2"'
    dev_args: '""'
    gain0: '30'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_am_demod_cf_0, '0', dc_blocker_xx_0, '0']
- [dc_blocker_xx_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', analog_am_demod_cf_0, '0']

metadata:
  file_format: 1
